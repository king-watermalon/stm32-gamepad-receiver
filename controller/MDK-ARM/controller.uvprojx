# Keil uVision project controller.uvprojx, settings and files
target controller (6210000::V6.21::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: controller +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=6
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: -fdata-sections -Wno-parentheses-equality
  c include: ..\Core\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Core/Src/: main.c ui.c keypad.c joystick.c battery.c led_rgb.c
  group Radio
    ../Core/Src/: si24r1.c
  group Display
    ../Core/Src/: oled.c oledfont.c cjkfont.c soft_i2c.c
  group USB
    ../Core/Src/: usb_comp.c
  group Debug
    ../Core/Src/: uart_dbg.c
  group CMSIS / Startup
    ../Core/Startup/: startup_stm32f103xb_keil.s
    ../Core/Src/: system_stm32f1xx.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group HAL Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c
